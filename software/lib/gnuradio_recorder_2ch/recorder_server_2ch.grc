options:
  parameters:
    generate_options: qt_gui
    id: recorder_server_2ch
    output_language: python
    title: recorder_server_2ch
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/parallels/Desktop/cw-code/data_sharppeak/sharppeak
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: '0.1'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1e-5'
    init: '0'
    low: '0.5e-5'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '10000'
    type: complex
  states: {state: disabled}
- name: cent_freq
  id: parameter
  parameters:
    label: Center frequency
    type: eng_float
    value: 430.0e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "from gnuradio import gr\nimport numpy as np\n\nimport os\nimport sys\nsys.path.append(os.getcwd())\nimport importlib\n\nimport pmt\n\nnon_module_func_printed=False\ndef non_module_func_body():\n    global non_module_func_printed\n    if not non_module_func_printed:\n        print(f\"NO EXPORT MODULE SELECTED\")\n        non_module_func_printed=True\n\ndef non_export_data(data):\n    non_module_func_body()\n\ndef non_handle_async_msg(msg):\n    non_module_func_body()\n\nclass PythonExportBlock(gr.sync_block):\n    def __init__(self, exportmodulename=None, samp_rate=-1):\n        gr.sync_block.__init__(\n            self,\n            name=\"PythonExportBlock\",\n            in_sig=[np.float32, np.float32],\n            out_sig=None\n        )\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern(\"cmd_out\"))\n\n        #self.exportmodulename = exportmodulename\n        if (exportmodulename is None):\n            self.exportmodule = None\n            self.process_data_func = non_export_data\n            self.handle_async_msg_func = non_handle_async_msg\n        else:\n            self.exportmodule = importlib.import_module(exportmodulename)\n            (getattr(self.exportmodule, \"init\"))(samp_rate)\n            self.process_data_func = getattr(self.exportmodule, \"export_data\")\n            self.handle_async_msg_func = getattr(self.exportmodule, \"handle_async_msg\")\n            setattr(self.exportmodule, \"send_async_msg_fn\", self.send_cmd)\n\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        return self.handle_async_msg_func(msg)\n\n    def send_cmd(self, msg):\n        return self.message_port_pub(pmt.intern(\"cmd_out\"), msg)\n\n    def work(self, input_items, output_items):\n        #print(len(input_items))\n        assert len(input_items) == 2\n        data = input_items[0]\n        #print(len(data))\n        trigger = input_items[1]\n        assert data.shape == trigger.shape\n        self.process_data_func(data, trigger)\n        #print(data[:10])  # do whatever you want\n        return len(data)\n\n"
    exportmodulename: '"recorder_server_2ch_export"'
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: cent_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_level: '0.001'
    type: float
  states: {state: disabled}
- name: rx_gain
  id: parameter
  parameters:
    label: RX gain
    type: intx
    value: '8'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 5e6
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: cent_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: cent_freq
    center_freq1: cent_freq
    gain0: rx_gain
    gain1: '8'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_selector_0, '0']
- [analog_quadrature_demod_cf_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '1']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [epy_block_0, cmd_out, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, async_msgs, epy_block_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
