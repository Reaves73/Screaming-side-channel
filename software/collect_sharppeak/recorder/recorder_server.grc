options:
  parameters:
    generate_options: qt_gui
    id: recorder_server
    output_language: python
    title: recorder_server
  states: {}

blocks:
- name: freq_shift
  id: variable
  parameters:
    value: 12.5e6
  states: {}
- name: lsb_freq
  id: variable_qtgui_range
  parameters:
    label: LSB Freq
    start: 425e6
    step: 1e6
    stop: 445e6
    value: 434e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.100'
    stop: '100'
    value: '0.500'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/parallels/Desktop/cw-code/data_sharppeak/sharppeak
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '10000'
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "from gnuradio import gr\nimport numpy as np\n\nimport os\nimport sys\n#print(f\"cwd: {os.getcwd()}\")\n#sys.path.append(\"/home/lindnera/data/SharpWhisperer/software/collect_sharppeak/recorder\")\nsys.path.append(os.getcwd())\nimport importlib\n#import mygoodcode\n\nnon_exportdata_printed=False\ndef non_exportdata(data):\n    global non_exportdata_printed\n    if not non_exportdata_printed:\n        print(f\"NO EXPORT MODULE SELECTED\")\n        non_exportdata_printed=True\n\nclass PythonExportBlock(gr.sync_block):\n    def __init__(self, exportmodulename=None):\n        gr.sync_block.__init__(\n            self,\n            name=\"PythonExportBlock\",\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        #self.exportmodulename = exportmodulename\n        if (exportmodulename is None):\n            self.exportmodule = None\n            self.processdata_func = non_exportdata\n        else:\n            self.exportmodule = importlib.import_module(exportmodulename)\n            (getattr(self.exportmodule, \"init\"))()\n            self.processdata_func = getattr(self.exportmodule, \"exportdata\")\n\n    def work(self, input_items, output_items):\n        data = input_items[0]        \n        #print(len(data))\n        #mygoodcode.processdata(data)\n        self.processdata_func(data)\n        #print(data[:10])  # do whatever you want\n        return len(data)\n\n"
    exportmodulename: '"recorder_server_export"'
  states: {}
- name: note_0
  id: note
  parameters:
    note: https://www.youtube.com/watch?v=XDkOhlztMLs
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: lsb_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: lsb_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: lsb_freq
    gain0: rf_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_selector_0, '0']
- [analog_quadrature_demod_cf_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_1, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
